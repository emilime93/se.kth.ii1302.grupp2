<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\digiboard-wifi.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\test-wifi\test.ewp</path>
    </project>
    <batchBuild />
</workspace>
